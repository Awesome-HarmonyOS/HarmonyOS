# IAR project Huawei_LiteOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411CE ST STM32F411CE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F411xE
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\Huawei_LiteOS\platform\bsp\sample\config\include; ..\..\..\..\Huawei_LiteOS\platform\bsp\sample\config; ..\..\..\..\Huawei_LiteOS\platform\cpu\arm\cortex-m4; ..\..\..\..\Huawei_LiteOS\kernel\include; ..\..\..\..\Huawei_LiteOS\kernel\base\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Huawei_LiteOS.bin
  ILINK.IlinkOutputFile: Huawei_LiteOS.out
  ILINK.IlinkIcfFile: Huawei_LiteOS_cortexMF411.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Huawei_LiteOS/kernel/base
    ../../../../Huawei_LiteOS/kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../../Huawei_LiteOS/kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../../../Huawei_LiteOS/kernel/base/misc/: los_misc.c
    ../../../../Huawei_LiteOS/kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
  group Huawei_LiteOS/platform/bsp
    ../../../../Huawei_LiteOS/platform/bsp/sample/config/: los_config.c
  group Huawei_LiteOS/platform/cpu
    ../../../../Huawei_LiteOS/platform/cpu/arm/cortex-m4/: los_dispatch.s los_hw.c los_hw_tick.c los_hwi.c los_vendor.s
