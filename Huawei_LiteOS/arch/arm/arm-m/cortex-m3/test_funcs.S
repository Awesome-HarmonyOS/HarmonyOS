 AREA sectionname ,CODE ,READONLY
 EXPORT TEST_NONALIGNED
 EXPORT TEST_PREFETCH
 EXPORT TEST_NOSUPERVISORVISIT
 EXPORT TEST_TOARM
TEST_NONALIGNED FUNCTION
	SUB   R13, #1
	MOV R0, #0X13
	PUSH {R1}
	POP {R1}
	ADD R13,#1
	BX LR
	ENDFUNC
TEST_PREFETCH FUNCTION
	MOV R0 , #0X1F000000
	ORR R0,R0,#0XFF0000
	ORR R0,R0,#0XC400
	MOV PC ,R0;0X1FFFC400 
	BX LR
	ENDFUNC

TEST_NOSUPERVISORVISIT FUNCTION
	MOV R0,#0XE0000000
	ORR R0,R0,#0X2200
	MOV PC,R0
	BX LR
	ENDFUNC
TEST_TOARM FUNCTION
	MOV R3,LR
	AND R3,0XFFFFFFFE
	BX R3
	ENDFUNC
END