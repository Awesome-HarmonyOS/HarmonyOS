<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Huawei_LiteOS</name>
    <group>
      <name>kernel</name>
      <group>
        <name>base</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Huawei_LiteOS\kernel\base\ipc\los_event.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Huawei_LiteOS\kernel\base\mem\los_membox.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Huawei_LiteOS\kernel\base\mem\los_memory.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Huawei_LiteOS\kernel\base\mem\los_memstat.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Huawei_LiteOS\kernel\base\misc\los_misc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Huawei_LiteOS\kernel\base\mem\los_multipledlinkhead.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Huawei_LiteOS\kernel\base\ipc\los_mux.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Huawei_LiteOS\kernel\base\core\los_priqueue.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Huawei_LiteOS\kernel\base\ipc\los_queue.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Huawei_LiteOS\kernel\base\ipc\los_sem.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Huawei_LiteOS\kernel\base\core\los_swtmr.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Huawei_LiteOS\kernel\base\core\los_sys.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Huawei_LiteOS\kernel\base\core\los_task.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Huawei_LiteOS\kernel\base\core\los_tick.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Huawei_LiteOS\kernel\base\core\los_timeslice.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>platform</name>
      <group>
        <name>bsp</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Huawei_LiteOS\platform\bsp\sample\config\los_config.c</name>
        </file>
      </group>
      <group>
        <name>cpu</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Huawei_LiteOS\platform\cpu\arm\cortex-m4\los_dispatch.s</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Huawei_LiteOS\platform\cpu\arm\cortex-m4\los_hw.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Huawei_LiteOS\platform\cpu\arm\cortex-m4\los_hw_tick.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Huawei_LiteOS\platform\cpu\arm\cortex-m4\los_hwi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Huawei_LiteOS\platform\cpu\arm\cortex-m4\los_vendor.s</name>
        </file>
      </group>
    </group>
  </group>
</project>


